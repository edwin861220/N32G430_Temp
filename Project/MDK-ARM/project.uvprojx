# Keil uVision project project.uvprojx, settings and files
target Flash (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32G430K8Q7 Nationstech
  pack: Nationstech.N32G430_DFP.1.2.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: output +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: N32G430,USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS\core;..\..\Libraries\CMSIS\device\startup;..\..\Libraries\n32g430_std_periph_driver\inc;..\..\Libraries\CMSIS\device;..\..\User\bsp;..\..\User\bsp\inc;..\..\User\cm_backtrace;..\..\User\cm_backtrace\Languages\zh-CN;..\..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group APP
    ../../User/: main.c
  group CMSIS
    ../../Libraries/CMSIS/device/: system_n32g430.c
  group MDK-ARM
    ../../Libraries/CMSIS/device/startup/: startup_n32g430.s
  group FWLIB
    ../../Libraries/n32g430_std_periph_driver/src/: misc.c n32g430_adc.c n32g430_beeper.c n32g430_can.c n32g430_comp.c n32g430_crc.c n32g430_dbg.c n32g430_dma.c n32g430_exti.c n32g430_flash.c n32g430_gpio.c n32g430_i2c.c n32g430_iwdg.c n32g430_lptim.c n32g430_pwr.c n32g430_rcc.c n32g430_rtc.c n32g430_spi.c n32g430_tim.c n32g430_usart.c n32g430_wwdg.c
